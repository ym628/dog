# Keil uVision project QuadrupedF405.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Quadruped +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\LED;..\HARDWARE\OLED;..\Quadruped\show;..\Quadruped\system;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\DMP;..\HARDWARE\MOTOR;..\Quadruped\Inverse;..\Quadruped\pid;..\Quadruped\Quadruped;..\HARDWARE\USARTX;..\HARDWARE\ADC;..\Quadruped\DataScope_DP;..\HARDWARE\PS2;..\Quadruped\GETCONTROL;..\HARDWARE\BEE;..\HARDWARE\CAN;..\HARDWARE\ENCODER;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group QUADRUPED
    ../Quadruped/system/: system.c
    ../Quadruped/Quadruped/: Quadruped.c
    ../Quadruped/Inverse/: Inverse.c
    ../Quadruped/pid/: pid.c
    ../Quadruped/show/: show.c
    ../Quadruped/DataScope_DP/: DataScope_DP.C
    ../Quadruped/GETCONTROL/: get_control.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/USARTX/: usartx.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/PS2/: pstwo.c
    ../HARDWARE/BEE/: BEE.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_can.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
